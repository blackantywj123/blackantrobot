# Keil uVision project Robort_Stm32.uvprojx, settings and files
target Robort_Stm32 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robort_Stm32 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\APP;..\..\Libraries\FWlib\inc;..\..\APP\Led;..\..\APP\TimBase;..\..\BSP;..\..\nmea_decode\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group APP
    ../../APP/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Common.h App_Steer.c App_Beep.c App_Light.c App_Message.c App_Motor.c App_Protocol.c App_Sensor.c App_Steer.h App_Beep.h App_Light.h App_Message.h App_Motor.h App_Protocol.h App_Sensor.h App_GPS.H App_GPS.c APP_Capture.c APP_MPU9250.c APP_MPU9250.h sys.c
  group DOC
    ../../Doc/: readme.txt
  group BSP
    ../../BSP/: BSP_Timer.c BSP_Timer.h BSP_Led.c BSP_Led.h BSP_Systick.c BSP_Systick.h BSP_Uart.c BSP_Uart.h BSP_Pwm.c BSP_Pwm.h BSP_Pantilt.c BSP_Pantilt.h BSP_ADC.C BSP_ADC.H BSP_Gpio.c BSP_Gpio.h BSP_GPS.c BSP_GPS.h BSP_IIC.c BSP_IIC.h
  group nmealib
    ../../nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
